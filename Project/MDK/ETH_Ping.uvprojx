# Keil uVision project ETH_Ping.uvprojx, settings and files
target APM32F107_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F107VC Geehy
  pack: Geehy.APM32F1xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ETH_Ping +hex
  AfterMake: fromelf --bin -o ./Objects/ETH_Ping.bin ./Objects/ETH_Ping.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: APM32F107_EVAL,APM32F10X_CL
  c misc: --no-multibyte-chars
  c include: ..\..\Include;..\..\..\ETH_Ping;..\..\Broads;..\..\Broads\Board_APM32F107_EVAL\inc;..\..\Broads\Board_APM32F107_EVAL\src;..\..\APM32F10x_ETH_Driver\inc;..\..\APM32F10x_ETH_Driver\src;..\..\APM32F10x_StdPeriphDriver\inc;..\..\APM32F10x_StdPeriphDriver\src;..\..\Broads\Board_APM32F107_EVAL\src;..\..\Broads\Board_APM32F107_EVAL\inc;..\..\LWIP\lwip-1.4.1\src\include\ipv4;..\..\LWIP\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\src\include\ipv4;..\..\LWIP\lwip-1.4.1\src\include\lwip;..\..\LWIP\lwip-1.4.1\src\include\netif;..\..\telnet;..\..\web;..\..\common;..\..\arch;..\..\system;..\..\APM32F10x_StdPeriphDriver\inc;..\..\Include;..\..\time;..\..\hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\ETH_Ping.sct
  group CMSIS
    ../../Core/: startup_apm32f10x_cl.s system_apm32f10x.c
  group APM32F10x_ETH_Driver
    ../../APM32F10x_ETH_Driver/src/: apm32f10x_eth.c
  group Boards
    ../../Broads/: Board.c
    ../../Broads/Board_APM32F107_EVAL/src/: bsp_lcd.c
  group Application
    ../../Source/: main.c ethernetif.c apm32f10x_int.c board_YT8522C.c SEGGER_RTT.c
    ../../Include/: SEGGER_RTT_Conf.h
  group APM32F10x_StdPeriphDriver
    ../../APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group lwip
    ../../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../LWIP/lwip-1.4.1/src/netif/: etharp.c
  group web
    ../../web/: http_server.c fs.c
  group user
    ./: sys_arch.c
  group System
    ../../system/: log_system.c log_system.h flash_storage.c flash_storage.h
  group time
    ../../time/: web_time_handler.c web_time_handler.h
  group hardware
    ../../hardware/: bsp_adc.c bsp_beeper.c bsp_led.c bsp_relay.c sys_config.c bsp_smoke_sensor.h bsp_smoke_sensor.c bsp_power_module.c bsp_power_module.h bsp_rs485.c bsp_rs485.h bsp_iap.c bsp_iap.h
