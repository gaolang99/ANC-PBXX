<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ETH_Ping.ewp</path>
    </project>
    <batchBuild />
</workspace>
