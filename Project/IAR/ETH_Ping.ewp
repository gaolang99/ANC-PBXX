# IAR project ETH_Ping.ewp, settings and files
configuration APM32F107_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: APM32F107VC Geehy APM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32F107_EVAL; APM32F10X_CL
  ICCARM.CCIncludePath2: ..\..\..\..\..\Boards; ..\..\..\..\..\Boards\Board_APM32F107_EVAL\inc; ..\..\Include; ..\..\..\..\..\Libraries\APM32F10x_ETH_Driver\inc; ..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Middlewares\lwip-1.4.1\src\include; ..\..\..\..\..\Middlewares\lwip-1.4.1\src\include\ipv4; ..\..\..\..\..\Middlewares\lwip-1.4.1\src\include\lwip; ..\..\..\..\..\Middlewares\lwip-1.4.1\src\include\netif; ..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include; ..\..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ETH_Ping.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APM32F1xx_ETH_Driver
    ../../../../../Libraries/APM32F10x_ETH_Driver/src/: apm32f10x_eth.c
  group Application
    ../../Source/: apm32f10x_int.c board_DP83848.c ethernetif.c main.c
  group Boards
    ../../../../../Boards/: Board.c
    ../../../../../Boards/Board_APM32F107_EVAL/src/: bsp_lcd.c
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F10x/Source/iar/: startup_apm32f10x_cl.s
    ../../Source/: system_apm32f10x.c
  group lwip-1.4.1
    ../../../../../Middlewares/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../Middlewares/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../Middlewares/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../Middlewares/lwip-1.4.1/src/netif/: etharp.c
  group StdPeriphDriver
    ../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
